# Repository ykstudio3695-boop/CHORDION

File README.md:

---

## プロジェクトのステータス

> **このプロジェクトは現在「プロトタイプ段階」です。**
> 日本の高校生が開発しており、将来的な**製品化**を目指しています。
> 仕様・回路・ファームウェアは予告なく変更されることがあります。

| 項目 | 内容 |
|---|---|
| 現在のフェーズ | プロトタイプ(Rev.2.0) |
| 目標 | 製品化・販売 |
| 開発者 | 日本の高校生2人 |
| 最終更新 | 2026/10/18 |

---

## 📖 目次

- [概要](#-概要)
- [デモ](#-デモ)
- [特徴](#-特徴)
- [仕様](#-仕様)
- [システム構成](#-システム構成)
- [ハードウェア](#-ハードウェア)
- [ファームウェア](#-ファームウェア)
- [ビルドと組み立て](#-ビルドと組み立て)
- [使い方](#-使い方)
- [リポジトリ構成](#-リポジトリ構成)
- [ロードマップ](#-ロードマップ)
- [既知の問題](#-既知の問題)
- [コントリビュート](#-コントリビュート)
- [ライセンス](#-ライセンス)
- [開発メンバー・連絡先](#-開発メンバー連絡先)

---

## 🎯 概要

ポケットサイズのシンセサイザーはそのサイズ故に機能が制限され、シンセサイザーの持つ表現の幅や**触った時の面白さ**が低下してしまうのが課題でした。
そこで私は演奏体験をより良いものにしようとハプティクスの概念をシンセサイザーに持ち込むことにしました。
これにより操作しているだけで楽しく、直感的で自然に操作になじむことができ、またユーザーに新たな体験をもたらしてくれる楽器を製作しようと考えたのです。
**それがChordionです。**

【開発のきっかけ、既存の製品にない点、目指す体験を3〜5行で書く】

<!-- 開発の動機を書くと、読んだ人に伝わりやすくなります -->

---

## 🎬 デモ

- 動画(YouTube等):【URL】
- SNS(開発の様子):【URL】

---

## ✨ 特徴

- **【特徴1】**:【説明】
- **【特徴2】**:【説明】
- **【特徴3】**:【説明】

---

## 📐 仕様

| 項目 | 内容 |
|---|---|
| マイコン/SoC | 【例:〇〇】 |
| 動作電圧 | 【例:5V (USB) / バッテリー〇V】 |
| 消費電流 | 【typ. 〇mA / max 〇mA】 |
| 入力 | 【ボタン・鍵盤・ノブ・センサー等】 |
| 出力 | 【オーディオ/MIDI/USB など】 |
| 通信 | 【USB-MIDI / UART / I2C / SPI / BLE など】 |
| 寸法 | 【W × D × H mm】 |
| 重量 | 【g】 |
| 電源 | 【USB給電 / 電池 / ACアダプタ】 |

---

## 🧩 システム構成

### ブロック図

【各ブロックの役割を簡潔に説明】

### ピンアサイン

| ピン | 信号名 | 接続先 | 備考 |
|---|---|---|---|
| 【例:D1】 | 【例:MIDI_TX】 | 【例:MIDIコネクタ】 | |
| | | | |

---

## 🔧 ハードウェア

### 回路図

- 回路図データ(KiCad / Eagle 等):[`hardware/schematic/`](hardware/schematic/)
- PDF:[`docs/schematic.pdf`](docs/schematic.pdf)

### 基板(PCB)

| 項目 | 内容 |
|---|---|
| 層数 | 【2層 / 4層】 |
| 基板サイズ | 【mm】 |
| 板厚 | 【1.6mm】 |
| 製造 | 【JLCPCB / PCBWay など】 |
| ガーバーデータ | [`hardware/gerber/`](hardware/gerber/) |

### 部品表(BOM)

| 部品番号 | 部品名 | 型番 | 数量 | 購入先 |
|---|---|---|---|---|
| U1 | 【マイコン】 | 【型番】 | 1 | 【秋月/Digi-Key/LCSC など】 |
| C1 | 【コンデンサ】 | 【0.1µF】 | 【数】 | |
| | | | | |

- 全部品リスト(CSV):[`hardware/bom.csv`](hardware/bom.csv)
- 概算コスト(1台あたり):【約〇〇円】

### 筐体・機構

- CAD データ(STEP / STL / Fusion360 等):[`hardware/enclosure/`](hardware/enclosure/)
- 製作方法:【3Dプリント / レーザーカット / 市販ケース加工】
- 3Dプリント設定:【材質 / 積層ピッチ / インフィル】

---

## 💾 ファームウェア

| 項目 | 内容 |
|---|---|
| 開発環境 | 【Arduino IDE / PlatformIO / Pico SDK など】 |
| 言語 | 【C++ / MicroPython など】 |
| 依存ライブラリ | 【ライブラリ名とバージョン】 |
| ソース | [`firmware/`](firmware/) |

### 書き込み手順

```bash
# 例:PlatformIO の場合
git clone https://github.com/【ユーザー名】/chordion.git
cd chordion/firmware
pio run -t upload
```

【書き込みモードへの入り方(ボタン長押しなど)があれば記載】

---

## 🛠 ビルドと組み立て

### 必要な道具

- はんだごて、はんだ、フラックス
- 【ピンセット、テスターなど】

### 手順

1. 基板を発注する(ガーバーデータは `hardware/gerber/`)
2. 部品を調達する(BOM を参照)
3. 表面実装部品 → スルーホール部品の順にはんだ付けする
4. 導通・電源電圧を確認する(**初回通電は電流制限付き電源を推奨**)
5. ファームウェアを書き込む
6. 筐体に組み込む

---

## 🎹 使い方

1. 【電源の入れ方】
2. 【基本操作】
3. 【接続方法(PC・スマホ・他機器)】

| 操作 | 動作 |
|---|---|
| 【ボタンA 短押し】 | 【動作】 |
| 【ボタンA 長押し】 | 【動作】 |

---

## 📁 リポジトリ構成

```
chordion/
├── README.md
├── LICENSE
├── docs/
│   └── images/          # README用の画像
├── hardware/
│   ├── schematic/       # 回路図
│   ├── pcb/             # 基板データ
│   ├── gerber/          # ガーバーデータ
│   ├── enclosure/       # 筐体CAD
│   └── bom.csv          # 部品表
└── firmware/            # ファームウェア
```

---

## 🗺 ロードマップ

- [x] 試作機(プロトタイプ)の製作
- [ ] 【機能追加・不具合修正】
- [ ] 基板の改版(Rev.B)
- [ ] ノイズ・安全性・耐久性の検証
- [ ] 量産に向けた設計の見直し
- [ ] 製品版の販売

---

## ⚠️ 既知の問題

| 内容 | 状態 | 対処・回避策 |
|---|---|---|
| 【例:〇〇でノイズが乗る】 | 調査中 | 【回避策】 |
| | | |

---

## 🤝 コントリビュート

プロトタイプ段階のため、フィードバックを歓迎します。

- バグ・要望:[Issues](../../issues)
- 改善提案:[Pull Request](../../pulls)
- 質問・感想:【SNS / Discussions】

---

## 📄 ライセンス

| 対象 | ライセンス |
|---|---|
| ハードウェア(回路・基板・筐体) | 【例:CERN-OHL-P / CERN-OHL-S など】 |
| ファームウェア | 【例:MIT / GPL-3.0 など】 |
| ドキュメント・画像 | 【例:CC BY 4.0】 |

> 製品化を予定しているため、商用利用の扱いは【方針を記載】。

---

## 👥 開発メンバー・連絡先

日本の高校生によるプロジェクトです。

- 開発者:【名前/ハンドルネーム】
- SNS:【URL】
- 連絡先:【メール or フォームのURL】

---

## 🙏 謝辞

【参考にしたプロジェクト、使用したライブラリ、協力してくれた人など】

## KiCad design ハードウェア/KiCad_data/pocket_synth.kicad_pcb

Parts:
BAT+1: BAT+; TestPoint_THTPad_2.0x2.0mm_Drill1.0mm
BAT-1: BAT-; TestPoint_THTPad_2.0x2.0mm_Drill1.0mm
C1, C2: 4.7μF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C3: 100nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; not fitted
C4: 10μF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; not fitted
C5, C8, C11, C16, C26: 0.1μF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C6: 47nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C7, C12, C13, C27: 10μF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C9, C10, C29, C30: 22μF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C14, C15, C18, C19, C20, C21, C22: 1μF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C17, C24, C25: 2.2μF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C23: 22μF; CP_Elec_6.3x5.2
CN1: SJ-3524-SMT-TR; AUDIO-SMD_SJ-3524-SMT-TR; MPN SJ-3524-SMT-TR; LCSC Part C20182907
Card1: TF PUSH; TF-SMD_TF-PUSH; MPN TF PUSH; LCSC Part C393941
D1, D2: SS12; D_SMA
FB1, FB2, FB3: FerriteBead; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
IC1: DRV10983PWP; SOP65P640X120-25N; MANUFACTURER_PART_NUMBER DRV10983PWP
J1: Motor_Pin; PinHeader_1x03_P2.54mm_Horizontal
J2: Conn_01x04_Pin; PinHeader_1x04_P2.54mm_Vertical; not fitted
J3: Conn_BLDC; PinHeader_1x04_P2.54mm_Vertical
J4: OLED; PinHeader_1x04_P2.54mm_Vertical
J6: 40mm 3W4Ω spk; PinHeader_1x02_P2.54mm_Vertical
L1: 47μH; IND_ASPI-6045S-470M-T
L2: 1.5μH; L_0805_2012Metric_Pad1.05x1.20mm_HandSolder
L3, L4: 1μH; IND_ASPI-6045S-470M-T
P1: USB_C_Plug_USB2.0; USB_C_Receptacle_XKB_U262-16XN-4BVC11
Q4: PMOS; SOT-23_Handsoldering
R1, R4, R5, R6, R9, R10, R12, R14: 100kΩ; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R2, R3: 5.1kΩ; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R7: 200Ω; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R8, R11: 10kΩ; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R13, R31: 13.3kΩ; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R15: 1kΩ; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; not fitted
R16, R17: 10kΩ; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; not fitted
R18: 33kΩ; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R21: PTA4543-2015DPB103; TRIM_PTA4543-2015DPB103; PARTREV 04/21; DigiKey_Part_Number PTA4543-2015DPB103-ND
R22: RK10J12E0A0A; DigiKey_Part_Number 4809-RK10J12E0A0A-ND
R23: 0Ω; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; not fitted
R24: 15kΩ; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R28, R30: 100kΩ; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R32: 20kΩ; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SDB1, SDB628: SOT-23-6
SW1, SW2, SW3, SW4, SW5, SW6, SW7, SW8, SW9: SW_Push; SW_PG1350
SW11: SW_Wuerth_450301014042; SW_Slide_SPDT_Angled_CK_OS102011MA1Q
TP1: DGND; TestPoint_Pad_D1.5mm
TP2: VCC; TestPoint_Pad_D1.5mm
TP3: SCL; TestPoint_Pad_D1.5mm
TP4: AI2; TestPoint_Pad_D1.5mm
TP5: AI1; TestPoint_Pad_D1.5mm
TP6: SDA; TestPoint_Pad_D1.5mm
TP13: DAC2; TestPoint_Pad_D1.5mm
TP14: DAC1; TestPoint_Pad_D1.5mm
TP15: GND; TestPoint_Pad_D1.5mm
TP16: SDBO; TestPoint_Pad_D1.5mm
U1: TPA2005D1DGNR; MSOP-8_L3.0-W3.0-P0.65-LS5.0-BL-EP; MPN TPA2005D1DGNR; LCSC Part C27396
U2: BQ25895RTW; Texas_RTW_WQFN-24-1EP_4x4mm_P0.5mm_EP2.7x2.7mm_ThermalVias
U4: Daisy_Seed; Electrosmith_Daisy_Seed
U5: TPA6132A2RTER; QFN50P300X300X80-16N; MPN TPA6132A2RTER
U6: AS5600; SOIC8; not fitted

Connections:
2: IC1.12 (FG), U4.25 (D18)
3V3_A: C26.1, C27.1, U1.6 (VDD), U4.21 (3V3_A), U5.14 (VDD)
5: IC1.14 (DIR), U4.26 (D19)
5V: C9.1, D2.1 (K), J3.4, J4.2, R28.1, TP2.1, U4.39 (VIN)
6: IC1.13 (SPEED), U4.24 (D17)
7: SW4.1, U4.8 (D7)
8: SW3.1, U4.9 (D8)
9: SW2.1, U4.10 (D9)
10: SW1.1, U4.11 (D10)
14: R22.2O, U4.22 (D15)
15: R21.2, U4.23 (D16)
20: SW5.1, U4.27 (D20)
21: SW6.1, U4.28 (D21)
22: R14.1, R18.2
24: SW7.1, U4.31 (D24)
25: SW8.1, U4.32 (D25)
26: SW9.1, U4.33 (D26)
AUDIO_L: C20.2, C25.1, U4.19 (AUDIO_OUT_2)
AUDIO_R: C21.2, U4.18 (AUDIO_OUT_1)
BAT_IN: BAT+1.1, C29.1, L4.1, R14.2, SDB1.4 (EN), SDB1.5 (VIN), U2.13 (BAT), U2.14 (BAT)
D+: P1.A6 (D+), U2.2 (D+), U4.37 (D30)
D-: P1.A7 (D-), U2.3 (D-), U4.36 (D29)
G_0: U4.14 (D13), U5.6 (G0)
G_1: U4.15 (D14), U5.7 (G1)
JSW: CN1.4, U4.35 (D28)
unnamed: C3.1, C4.2, J2.2, R15.1, U6.4 (GND)
unnamed: C3.2, J2.1, R16.2, R17.2, R23.2, U6.1 (VDD5V)
unnamed: C4.1, R23.1, U6.2 (VDD3V3)
unnamed: C6.2, L2.2
unnamed: C24.2, R9.2, R10.2
unnamed: C25.2, R1.2, R4.2
unnamed: Card1.2 (CD/DAT3), U4.2 (D1)
unnamed: Card1.5 (CLX), U4.7 (D6)
unnamed: Card1.3 (CMD), U4.6 (D5)
unnamed: Card1.7 (DAT0), U4.5 (D4)
unnamed: Card1.8 (DAT1), U4.4 (D3)
unnamed: Card1.1 (DAT2), U4.3 (D2)
unnamed: D1.2 (A), L4.2, SDB1.1 (SW)
unnamed: D2.2 (A), L3.2, SDB628.1 (SW)
unnamed: C11.1, IC1.3 (CPN)
unnamed: C11.2, IC1.2 (CPP)
unnamed: IC1.4 (SW), L1.2
unnamed: FB3.1, IC1.17 (U(1)), IC1.18 (U(2))
unnamed: C14.2, IC1.7 (V1P8)
unnamed: C15.2, IC1.9 (V3P3)
unnamed: FB2.1, IC1.19 (V(1)), IC1.20 (V(2))
unnamed: C5.2, IC1.1 (VCP)
unnamed: C12.2, IC1.6 (VREG), L1.1
unnamed: FB1.1, IC1.21 (W(1)), IC1.22 (W(2))
unnamed: FB1.2, J1.1
unnamed: FB2.2, J1.2
unnamed: FB3.2, J1.3
unnamed: J2.3, R17.1, U6.6 (SDA)
unnamed: J2.4, R16.1, U6.7 (SCL)
unnamed: J6.1, U1.5 (VO+)
unnamed: J6.2, U1.8 (VO-)
unnamed: L2.1, U2.19 (SW), U2.20 (SW)
unnamed: P1.A5 (CC), R2.1
unnamed: P1.B5 (VCONN), R3.1
unnamed: C10.1, L3.1, Q4.1 (D), SDB628.4 (EN), SDB628.5 (VIN)
unnamed: Q4.3 (S), SW11.1 (B)
unnamed: R15.2, U6.5 (PGO)
unnamed: R24.1, R30.2, R31.1, R32.1, SDB1.3 (FB)
unnamed: R13.1, R28.2, SDB628.3 (FB)
unnamed: R1.1, R4.1, U1.3 (IN+)
unnamed: R9.1, R10.1, U1.4 (IN-)
unnamed: C6.1, U2.21 (BTST)
unnamed: R7.2, U2.10 (ILIM)
unnamed: R5.2, U2.8 (OTG)
unnamed: C1.1, U2.23 (PMID)
unnamed: C2.1, R11.2, U2.22 (REGN)
unnamed: R8.2, R11.1, U2.11 (TS)
unnamed: C22.2, C23.1, P1.A4 (VBUS), P1.A9 (VBUS), P1.B4 (VBUS), P1.B9 (VBUS), U2.1 (VBUS)
unnamed: R6.2, U2.12 (~QON)
unnamed: TP5.1, U4.16 (AUDIO_IN_1)
unnamed: TP4.1, U4.17 (AUDIO_IN_2)
unnamed: TP13.1, U4.29 (D22)
unnamed: TP14.1, U4.30 (D23)
unnamed: C18.2, U5.9 (CPN)
unnamed: C18.1, U5.11 (CPP)
unnamed: C17.2, U5.12 (HPVDD)
unnamed: C19.2, U5.8 (HPVSS)
unnamed: C20.1, U5.1 (INL-)
unnamed: C21.1, U5.4 (INR-)
unnamed: CN1.3, U5.16 (OUTL)
unnamed: CN1.2, U5.5 (OUTR)
SCL: IC1.10 (SCL), J3.1, J4.3, TP3.1, U2.5 (SCL), U4.12 (D11)
SD: U1.1 (SHUTDOWN), U4.34 (D27)
SDA: IC1.11 (SDA), J3.2, J4.4, TP6.1, U2.6 (SDA), U4.13 (D12)
SDB_OUT: C5.1, C13.1, C16.1, C30.1, D1.1 (K), IC1.23 (VCC(1)), IC1.24 (VCC(2)), R30.1, TP16.1
TPA_EN: U4.1 (D0), U5.13 (EN)
TPS_IN: C7.1, C8.1, SW11.2 (C), U2.15 (SYS), U2.16 (SYS)
microB+: Q4.2 (G), R12.1

Notes on the sheet:
スライドボリューム[LFO/ピッチ用]
BLDCモータードライバ回路
音量調節用可変抵抗
BLDC基板コネクタ
OLEDディスプレイ
電源昇圧回路 / IN[3.7-5V] OUT[5.1V]
バッテリー残量取得
マイコン / Daisy Seed
外部機器接続コネクタ[ポゴピン]
オーディオ生成・再生部 / TPA6132A
その他デバイス・ボタン・抵抗
電源回路 / [micro-b][type-c][1500mAh/3A BAT]電源入力
鍵盤 + ファンクション
モータードライバ昇圧回路 / IN[3.7-4.2V] OUT[12.1V]
IC直近に配置

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
Board: 2 copper layers, 88.0 x 119.9 mm, 94 parts (17 on the bottom side), 89 nets.

## Commit log (part)

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2026-06-28 Add CAD tools and descriptions
2026-06-28 Create BOM for CHORDION hardware components
    Added a Bill of Materials (BOM) for CHORDION hardware components in both English and Japanese.
2026-06-28 Rename CAD to CAD.md
2026-06-28 Revise BOM with detailed components and links
    Updated the Bill of Materials (BOM) to include specific components and their sources.
2026-06-28 Create a
2026-06-28 Create documentation for Teensy test program
    Added documentation for Teensy test program, including requirements and important notices in both English and Japanese.
